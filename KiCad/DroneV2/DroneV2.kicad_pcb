# Repository DrCampy/Drone

## KiCad design KiCad/DroneV2/DroneV2.kicad_pcb

Parts:
BUZ1: Buzzer; MagneticBuzzer_StarMicronics_HMB-06_HMB-12
C1, C2: C; C_Rect_L7_W2_P5
CH1, CH2, CH3, CH4: Rx_Pin; Pin_Header_Straight_1x03
ESC1, ESC2, ESC3, ESC4: ESC_Connecor; Pin_Header_Straight_1x03
U1: GY-80; GY-80-Footprint
U2: ARDUINO_MICRO_SHIELD
U3: LM7809CT; TO-220_Neutral123_Vertical
U4: Battery_Connector; Pin_Header_Angled_1x03

Connections:
+5V: CH1.2 (+), CH2.2 (+), CH3.2 (+), CH4.2 (+), U2.5V
/ARDUINO_3.3V: U1.2 (VCC_3.3V), U2.3.3V
GND: BUZ1.2 (-), C1.2, C2.2, CH1.3 (GND), CH2.3 (GND), CH3.3 (GND), CH4.3 (GND), ESC1.3 (GND), ESC2.3 (GND), ESC3.3 (GND), ESC4.3 (GND), U1.3 (GND), U2.GND, U3.2 (GND), U4.3 (-)
unnamed: BUZ1.1 (+), U2.4
unnamed: C1.1, U2.VI, U3.3 (OUT)
unnamed: C2.1, U3.1 (IN), U4.1 (+)
unnamed: CH1.1 (Signal), U2.8
unnamed: CH2.1 (Signal), U2.9
unnamed: CH3.1 (Signal), U2.10
unnamed: CH4.1 (Signal), U2.11
unnamed: ESC1.1 (Signal), U2.A3
unnamed: ESC2.1 (Signal), U2.A2
unnamed: ESC3.1 (Signal), U2.A1
unnamed: ESC4.1 (Signal), U2.A0
unnamed: U1.4 (SCL), U2.3
unnamed: U1.5 (SDA), U2.2

Board: 2 copper layers, 70.0 x 70.0 mm, 15 parts (0 on the bottom side), 16 nets.

## Commit log

2016-04-06 Importing all the already existing files on Git
2016-04-06 Changing pads width and track's layer
    Tracks are now on the bottom copper layer.
    Pads are wider (oval) with a smaller hole in the middle
2016-04-13 Mise à jour PCB
2018-06-19 Changing sketch's name
2018-06-19 Class Motor
    Class Motor.
    Manages the communication with the ESCs
2018-06-19 Class Receiver
    Manages the reading of the values from the RC receiver
2018-06-28 gy80 class
2018-06-29 Main Sketch
    Ajout du filtre madgwick
2018-06-29 PID class
    implementing the PID class and algorithm
2018-06-29 Clearing main sketch
    clearing main sketch of lot of old stuff
2018-06-29 enable/disable receiver interrupts
    Allows us to enable/disable the readings(interrupts) of the receiver
2018-07-25 Randoms changes (whitespace...) + comments
2018-07-30 Random aesthetic changes
2018-07-30 Progress on the core of the program. Cleaning old lines.
2018-09-07 Main sketch advancement
2018-09-08 Revert "Merge branch 'Reformation-code-OOP' of https://github.com/DrCampy/Drone into Reformation-code-OOP"
    This reverts commit 467b3361e46c6f3a20ade97d6a60ce463125d958, reversing
    changes made to af295835a3a6bfe8f4fc44d65110ed28befc80a1.
